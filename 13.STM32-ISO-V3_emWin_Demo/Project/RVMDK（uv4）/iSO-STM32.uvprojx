# Keil uVision project iSO-STM32.uvprojx, settings and files
target emWin_basic (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\STemWinLibrary522\inc;..\..\STemWinLibrary522\Config;..\..\Demo;..\..\ff10;..\..\ff10\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/usart/: bsp_usart1.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/spi_flash/: fatfs_flash_spi.c
    ../../User/ExSRAM/: bsp_fsmc_sram.c
  group STemWin_V522
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/OS/: GUI_X.c GUI_X_Touch_Analog.c
  group DOC
    ../../Doc/: readme.txt
  group Demo
    ../../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group ff10
    ../../ff10/: diskio.c ff.c
    ../../ff10/option/: ccsbcs.c
software components: CMSIS:CORE 4.1.0
