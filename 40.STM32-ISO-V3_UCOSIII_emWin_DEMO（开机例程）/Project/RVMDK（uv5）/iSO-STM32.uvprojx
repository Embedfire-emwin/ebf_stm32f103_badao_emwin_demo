# Keil uVision project iSO-STM32.uvprojx, settings and files
target uCOS_emWin (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\app;..\..\STemWinLibrary522\Config;..\..\STemWinLibrary522\inc;..\..\ff10;..\..\ff10\option;..\..\User\os;..\..\Mass_Storage\inc;..\..\STM32_USB-FS-Device_Driver\inc;..\..\User\bsp\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group BSP
    ../../User/bsp/: bsp.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/usart/: bsp_usart1.c
    ../../User/bsp/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/bsp/ExSRAM/: bsp_fsmc_sram.c
    ../../User/bsp/spi_flash/: fatfs_flash_spi.c
    ../../User/bsp/Key/: key.c
    ../../User/bsp/Beep/: beep.c
    ../../User/bsp/TouchPad/: TouchPad.c
    ../../User/bsp/EEPROM/: bsp_i2c_ee.c bsp_i2c_gpio_ee.c
    ../../User/bsp/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../../User/bsp/vs1053/: VS1053.c
    ../../User/bsp/sdcard/: bsp_sdio_sdcard.c
    ../../User/bsp/ov7725/: bsp_ov7725.c bsp_sccb.c
    ../../User/bsp/sim900a/: sim900a.c bsp_usart2.c
    ../../User/bsp/breathinglight/: bsp_breathing.c
    ../../User/bsp/ESP8266/: bsp_esp8266.c
  group os_cfg
    ../../User/os/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group app
    ../../User/: includes.h common.c
    ../../User/app/: app.h app.c appicon.c Touch_CalibrationApp.c KEYapp.c Breathingapp.c ADCapp.c EEPROMapp.c keypadapp.c pysearch.c Clockapp.c Musicapp.c Recorderapp.c USBapp.c Humitureapp.c Cameraapp.c Phoneapp.c Messageapp.c Calculatorapp.c PICTUREapp.c Noteapp.c Browserapp.c W5500app.c Wifi.c
  group STemWin_V522
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
    ../../STemWinLibrary522/OS/: GUI_X_uCOS.c GUI_X_Touch_Analog.c
  group ff10
    ../../ff10/: diskio.c ff.c firecc936.c
  group STM32_USB-FS-Device_Driver
    ../../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Mass_Storage
    ../../Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group w5500
    ../../User/bsp/W5500/: socket.c utility.c w5500.c w5500_conf.c
    ../../User/bsp/W5500/dhcp/: dhcp.c
    ../../User/bsp/TimBase/: bsp_TiMbase.c
software components: CMSIS:CORE 4.1.0
